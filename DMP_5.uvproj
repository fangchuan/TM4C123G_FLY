# Keil uVision project DMP_5.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: DMP_5
  c flags: Optim=1 wLevel=1
  c define: rvmdk PART_LM4F232H5QD MPU9150 TARGET_IS_BLIZZARD_RA1
  c include: F:\MSP430\TM4C123\HANKERLM4F232\HANKERLM4F232\Code
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Startup.s
  group APP
    ./: inv_mpu.c inv_mpu_dmp_motion_driver.c debug.c main.c mpu_tool.c ccdandcsb.c cmd.c AP_OpticalFlow_ADNS3080.c AP_OpticalFlow.c
  group LIB
    F:/MSP430/TM4C123/HANKERLM4F232/HANKERLM4F232/Code/driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
  group communication
    ./: MPU6050.c uartstdio.c ustdlib.c UART_user.c usart.c
  group sysytem
    ./: Sys.c
  group TIMER
    ./: Timer_user.c
  group PID
    ./: FC_PI.c FC_PID.c Parameters.c
  group AP_MOTOR
    ./: AP_MotorsQuard.C PWM.c
  group AP_AHRS
    ./: AP_AHRS_DCM.c AP_Baro.c AP_BufferFloat.c AP_Inertial_Nav.c
  group AP_CONTROL
    ./: ArduCopter.c rate_controller.c RC_Channel.c
  group MATH
    ./: AP_Math.c Matrix3f.c Vector3f.c
  group DELAY
    ./: delay.c
